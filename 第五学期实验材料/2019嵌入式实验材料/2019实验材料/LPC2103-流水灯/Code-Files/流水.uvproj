# Keil uVision project 流水.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: LPC2103 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 流水
  group Source Files
    ./: Startup.s liushui.c
